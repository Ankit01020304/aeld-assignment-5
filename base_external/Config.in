## base_external/Config.in
```kconfig
menu "AESD External Options"

source "$BR2_EXTERNAL_PROJECT_BASE_PATH/package/aesd-assignments/Config.in"

endmenu
```
